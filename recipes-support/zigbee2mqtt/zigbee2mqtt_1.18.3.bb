# Recipe created by recipetool
# This is the basis of a recipe and may need further editing in order to be fully functional.
# (Feel free to remove these comments when editing.)

SUMMARY = "Zigbee to MQTT bridge using Zigbee-herdsman"
HOMEPAGE = "https://koenkk.github.io/zigbee2mqtt"
# WARNING: the following LICENSE and LIC_FILES_CHKSUM values are best guesses - it is
# your responsibility to verify that the values are complete and correct.
#
# The following license files were not able to be identified and are
# represented as "Unknown" below, you will need to check them yourself:
#   node_modules/fs.realpath/LICENSE
#   node_modules/balanced-match/LICENSE.md
#   node_modules/string_decoder/LICENSE
#   node_modules/tar-stream/node_modules/readable-stream/LICENSE
#   node_modules/uri-js/LICENSE
#   node_modules/through2/LICENSE.md
#   node_modules/tunnel-agent/LICENSE
#   node_modules/colors/LICENSE
#   node_modules/winston/node_modules/readable-stream/LICENSE
#   node_modules/glob/LICENSE
#   node_modules/humanize-duration/LICENSE.txt
#   node_modules/detect-libc/LICENSE
#   node_modules/rc/LICENSE.APACHE2
#   node_modules/rc/LICENSE.BSD
#   node_modules/bl/LICENSE.md
#   node_modules/bl/node_modules/readable-stream/LICENSE
#   node_modules/mqtt-packet/LICENSE.md
#   node_modules/sprintf-js/LICENSE
#   node_modules/readable-stream/LICENSE
#   node_modules/nan/LICENSE.md
#   node_modules/slip/GPL-LICENSE.txt
#   node_modules/ieee754/LICENSE
#   node_modules/process-nextick-args/license.md
#   node_modules/split2/node_modules/readable-stream/LICENSE
#   node_modules/esprima/LICENSE.BSD
#   node_modules/zigbee2mqtt-frontend/LICENSE
#   node_modules/zigbee2mqtt-frontend/dist/scripts/vendor.46f2f1bd08054c950eed.js.LICENSE.txt
#   node_modules/typedarray/LICENSE
#   node_modules/mqtt/LICENSE.md
#
# NOTE: multiple licenses have been detected; they have been separated with &
# in the LICENSE value for now since it is a reasonable assumption that all
# of the licenses apply. If instead there is a choice between the multiple
# licenses then you should change the value to separate the licenses with |
# instead of &. If there is any doubt, check the accompanying documentation
# to determine which situation is applicable.
LICENSE = "GPLv3 & MIT & ISC & Unknown"
LIC_FILES_CHKSUM = "file://LICENSE;md5=84dcc94da3adb52b53ae4fa38fe49e5d \
                    file://node_modules/ee-first/LICENSE;md5=c8d3a30332ecb31cfaf4c0a06da18f5c \
                    file://node_modules/@serialport/bindings/LICENSE;md5=e2bc0aa64d278eb2b6ddeb692e294945 \
                    file://node_modules/@serialport/bindings/node_modules/ms/license.md;md5=fd56fd5f1860961dfa92d313167c37a6 \
                    file://node_modules/@serialport/bindings/node_modules/debug/LICENSE;md5=ddd815a475e7338b0be7a14d8ee35a99 \
                    file://node_modules/@serialport/parser-ready/LICENSE;md5=e2bc0aa64d278eb2b6ddeb692e294945 \
                    file://node_modules/@serialport/binding-mock/LICENSE;md5=e2bc0aa64d278eb2b6ddeb692e294945 \
                    file://node_modules/@serialport/binding-mock/node_modules/ms/license.md;md5=fd56fd5f1860961dfa92d313167c37a6 \
                    file://node_modules/@serialport/binding-mock/node_modules/debug/LICENSE;md5=ddd815a475e7338b0be7a14d8ee35a99 \
                    file://node_modules/@serialport/parser-regex/LICENSE;md5=e2bc0aa64d278eb2b6ddeb692e294945 \
                    file://node_modules/@serialport/parser-readline/LICENSE;md5=e2bc0aa64d278eb2b6ddeb692e294945 \
                    file://node_modules/@serialport/stream/LICENSE;md5=e2bc0aa64d278eb2b6ddeb692e294945 \
                    file://node_modules/@serialport/stream/node_modules/ms/license.md;md5=fd56fd5f1860961dfa92d313167c37a6 \
                    file://node_modules/@serialport/stream/node_modules/debug/LICENSE;md5=ddd815a475e7338b0be7a14d8ee35a99 \
                    file://node_modules/@serialport/parser-inter-byte-timeout/LICENSE;md5=e2bc0aa64d278eb2b6ddeb692e294945 \
                    file://node_modules/@serialport/parser-byte-length/LICENSE;md5=e2bc0aa64d278eb2b6ddeb692e294945 \
                    file://node_modules/@serialport/binding-abstract/LICENSE;md5=e2bc0aa64d278eb2b6ddeb692e294945 \
                    file://node_modules/@serialport/binding-abstract/node_modules/ms/license.md;md5=fd56fd5f1860961dfa92d313167c37a6 \
                    file://node_modules/@serialport/binding-abstract/node_modules/debug/LICENSE;md5=ddd815a475e7338b0be7a14d8ee35a99 \
                    file://node_modules/@serialport/parser-cctalk/LICENSE;md5=e2bc0aa64d278eb2b6ddeb692e294945 \
                    file://node_modules/@serialport/parser-delimiter/LICENSE;md5=e2bc0aa64d278eb2b6ddeb692e294945 \
                    file://node_modules/ansi-regex/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/moment/LICENSE;md5=397bb5fedab22612d8d69f1458a9321e \
                    file://node_modules/wrappy/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/serialport/LICENSE;md5=e2bc0aa64d278eb2b6ddeb692e294945 \
                    file://node_modules/serialport/node_modules/ms/license.md;md5=fd56fd5f1860961dfa92d313167c37a6 \
                    file://node_modules/serialport/node_modules/debug/LICENSE;md5=ddd815a475e7338b0be7a14d8ee35a99 \
                    file://node_modules/fs.realpath/LICENSE;md5=062470525c8e380f8567f665ef554d11 \
                    file://node_modules/balanced-match/LICENSE.md;md5=7fa99ddc3424107350ca6e9a24552085 \
                    file://node_modules/help-me/LICENSE;md5=6c5e18034ed4abefcb9ac97254596680 \
                    file://node_modules/string_decoder/LICENSE;md5=14af51f8c0a6c6e400b53e18c6e5f85c \
                    file://node_modules/node-abi/LICENSE;md5=950ded031080d1cc5efffec127b7a852 \
                    file://node_modules/node-abi/node_modules/semver/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/ms/license.md;md5=fd56fd5f1860961dfa92d313167c37a6 \
                    file://node_modules/mkdirp-classic/LICENSE;md5=9d0b3b7764a2c71b14f36865c1d30feb \
                    file://node_modules/simple-concat/LICENSE;md5=fb42e5aa12bb9e365d38b4b5691d6984 \
                    file://node_modules/mime/LICENSE;md5=8e8ea2ad138ce468f8570a0edbadea65 \
                    file://node_modules/es6-set/LICENSE;md5=8c48678fbd286186af08f3483ad30ba9 \
                    file://node_modules/es6-set/node_modules/es6-symbol/LICENSE;md5=ee542ce23bb66820e33194d9ce8ebcf0 \
                    file://node_modules/es6-symbol/LICENSE;md5=6bb4a97bc66f66495cb0ee21fe1af526 \
                    file://node_modules/deep-extend/LICENSE;md5=827bb5781213ff1e9d2fe309bbfc0115 \
                    file://node_modules/prebuild-install/LICENSE;md5=a75272c6b584d0f8e2c1676b4e72469e \
                    file://node_modules/async/LICENSE;md5=73f63c1fa4541b2f2f34d77140ebe89d \
                    file://node_modules/is-fullwidth-code-point/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/brace-expansion/LICENSE;md5=a5df515ef062cc3affd8c0ae59c059ec \
                    file://node_modules/buffer/LICENSE;md5=e49e579dbcc02cf1f699deec85fd96f0 \
                    file://node_modules/fecha/LICENSE;md5=f4f83e94071a71d564921579ec889591 \
                    file://node_modules/tar-stream/LICENSE;md5=9befe7026bf915886cd566a98117c80e \
                    file://node_modules/tar-stream/node_modules/readable-stream/LICENSE;md5=a67a7926e54316d90c14f74f71080977 \
                    file://node_modules/color-name/LICENSE;md5=d301869b39e08b33665b7c4f16b8e41d \
                    file://node_modules/event-emitter/LICENSE;md5=12a2129052783ef689cde41f4d302e6b \
                    file://node_modules/buffer-crc32/LICENSE;md5=b27a845c0955487ec9ca7b4ff7295b2b \
                    file://node_modules/http-errors/LICENSE;md5=607209623abfcc77b9098f71a0ef52f9 \
                    file://node_modules/ordered-read-streams/LICENSE;md5=2c136e62d89cbaf1bb1aa0e6002c3c5b \
                    file://node_modules/enabled/LICENSE;md5=c306c558012a48012189a646e0635014 \
                    file://node_modules/es5-ext/LICENSE;md5=9892f85a586bbc7ec0d9410b8e369309 \
                    file://node_modules/mixin-deep/LICENSE;md5=0f64900f8f30e53054962c9f1fc3205b \
                    file://node_modules/bindings/LICENSE.md;md5=471723f32516f18ef36e7ef63580e4a8 \
                    file://node_modules/statuses/LICENSE;md5=36e2bc837ce69a98cc33a9e140d457e5 \
                    file://node_modules/yallist/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/stream-shift/LICENSE;md5=42014010547e55bd3bcac2fec8c45624 \
                    file://node_modules/send/LICENSE;md5=df2b0938eba0709b77ac937e2d552b7a \
                    file://node_modules/send/node_modules/ms/license.md;md5=fd56fd5f1860961dfa92d313167c37a6 \
                    file://node_modules/util-deprecate/LICENSE;md5=b7c99ef4b0f3ad9911a52219947f8cf0 \
                    file://node_modules/fs-constants/LICENSE;md5=0033175ba371b569c73d23fd726c37e8 \
                    file://node_modules/ws/LICENSE;md5=95833e8f03687308b0584a377b9e12b0 \
                    file://node_modules/uri-js/LICENSE;md5=3b55dad4a98748003b5b423477713da1 \
                    file://node_modules/through2/LICENSE.md;md5=86fc40a92fe89e4ec72daa6fab2f9c21 \
                    file://node_modules/tunnel-agent/LICENSE;md5=f3f8ead5440d1c311b45be065d135d90 \
                    file://node_modules/stack-trace/License;md5=9fbf93f7a763e64c0a30207b5693bf75 \
                    file://node_modules/finalhandler/LICENSE;md5=b506956e5cbfbe0d04f8a5c40107ec89 \
                    file://node_modules/concat-stream/LICENSE;md5=3ad90c134f824ddfcea611ee1fa567a8 \
                    file://node_modules/colors/LICENSE;md5=441ee46669f9365ff2492e9b555c8ee7 \
                    file://node_modules/simple-swizzle/LICENSE;md5=5db33c6d7c83b57f204826cb21400b88 \
                    file://node_modules/color-string/LICENSE;md5=330031db3ec2b47f6e9d7923b8e1f95b \
                    file://node_modules/ini/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/winston/LICENSE;md5=124783bb03d1b801c23d11f07b62be0a \
                    file://node_modules/winston/node_modules/readable-stream/LICENSE;md5=a67a7926e54316d90c14f74f71080977 \
                    file://node_modules/glob/LICENSE;md5=c727d36f28f2762b1011dd483aa1a191 \
                    file://node_modules/humanize-duration/LICENSE.txt;md5=f4c62131f879a8445e16a7f265aea635 \
                    file://node_modules/fast-safe-stringify/LICENSE;md5=d06834a8b49bbad54ea80bd501ce4bdc \
                    file://node_modules/npmlog/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/detect-libc/LICENSE;md5=e3fc50a88d0a364313df4b21ef20c29e \
                    file://node_modules/unique-stream/LICENSE;md5=64386b1e25291dbfa6fc2a6631a8eef5 \
                    file://node_modules/argparse/LICENSE;md5=a2f2590d8d82b0fa2b3e2fc5c69d2b81 \
                    file://node_modules/d/LICENSE;md5=6bb4a97bc66f66495cb0ee21fe1af526 \
                    file://node_modules/winston-transport/LICENSE;md5=05a0729dc3291972c7b9e521a99a3c1f \
                    file://node_modules/once/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/string-width/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/depd/LICENSE;md5=13babc4f212ce635d68da544339c962b \
                    file://node_modules/es6-map/LICENSE;md5=8c48678fbd286186af08f3483ad30ba9 \
                    file://node_modules/range-parser/LICENSE;md5=d4246fb961a4f121eef5ffca47f0b010 \
                    file://node_modules/rc/LICENSE.APACHE2;md5=ffcf739dca268cb0f20336d6c1a038f1 \
                    file://node_modules/rc/LICENSE.MIT;md5=e0f70a42adf526e6f5e605a94d98a420 \
                    file://node_modules/rc/LICENSE.BSD;md5=e7a2a325a0069e82aff675bbf74464a0 \
                    file://node_modules/follow-redirects/LICENSE;md5=2913574e921aefe1275cd5864b4f9b66 \
                    file://node_modules/ajv/LICENSE;md5=4973982316cdc12e988b814af2813df7 \
                    file://node_modules/next-tick/LICENSE;md5=19e92c67c9fee20f1142fc69b45d46ff \
                    file://node_modules/axios/LICENSE;md5=61ca8e74b70ea19443b95af4bd607999 \
                    file://node_modules/setprototypeof/LICENSE;md5=4846f1626304c2c0f806a539bbc7d54a \
                    file://node_modules/deep-object-diff/LICENSE;md5=61788eaf39dfee706067bec36c870763 \
                    file://node_modules/pumpify/LICENSE;md5=9befe7026bf915886cd566a98117c80e \
                    file://node_modules/pumpify/node_modules/pump/LICENSE;md5=9befe7026bf915886cd566a98117c80e \
                    file://node_modules/is-windows/LICENSE;md5=5fb5a7fdbcfa3640822ec69bd3ee86e7 \
                    file://node_modules/type/LICENSE;md5=ed9f856e8c22ce11bfc3fc55222bfdb6 \
                    file://node_modules/debug/LICENSE;md5=ddd815a475e7338b0be7a14d8ee35a99 \
                    file://node_modules/json-schema-traverse/LICENSE;md5=ea87ade09b9e6da4f2e47904a4ee137b \
                    file://node_modules/semver/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/toidentifier/LICENSE;md5=1a261071a044d02eb6f2bb47f51a3502 \
                    file://node_modules/is-relative/LICENSE;md5=3d83ea4c8ec9b31d9ff2c82fa29beabb \
                    file://node_modules/json-stable-stringify-without-jsonify/LICENSE;md5=aea1cde69645f4b99be4ff7ca9abcce1 \
                    file://node_modules/is-extglob/LICENSE;md5=97b255bb4707da164bfaf4e5c7b9f9ef \
                    file://node_modules/agent-base/node_modules/ms/license.md;md5=fd56fd5f1860961dfa92d313167c37a6 \
                    file://node_modules/agent-base/node_modules/debug/LICENSE;md5=ddd815a475e7338b0be7a14d8ee35a99 \
                    file://node_modules/is-negated-glob/LICENSE;md5=d5d7b190ec11a5e3199c3b3b45cde690 \
                    file://node_modules/concat-map/LICENSE;md5=aea1cde69645f4b99be4ff7ca9abcce1 \
                    file://node_modules/napi-build-utils/LICENSE;md5=422bf72cc7bd42f1141b39eb8bac7903 \
                    file://node_modules/fast-deep-equal/LICENSE;md5=ea87ade09b9e6da4f2e47904a4ee137b \
                    file://node_modules/is-unc-path/LICENSE;md5=78c705080a639d3bb4085a9d1bb22987 \
                    file://node_modules/js-yaml/LICENSE;md5=effd621a9bf5d72d6a7e6ef819bf3afb \
                    file://node_modules/rimraf/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/minimatch/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/text-hex/LICENSE;md5=d699750183031d92d152d4fb1270b705 \
                    file://node_modules/strip-json-comments/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/https-proxy-agent/node_modules/ms/license.md;md5=fd56fd5f1860961dfa92d313167c37a6 \
                    file://node_modules/https-proxy-agent/node_modules/debug/LICENSE;md5=ddd815a475e7338b0be7a14d8ee35a99 \
                    file://node_modules/glob-stream/LICENSE;md5=59d5f6a97c4befff1e4f1c67abc598c2 \
                    file://node_modules/reinterval/LICENSE;md5=c65ef22a386436c433298ca42418c200 \
                    file://node_modules/punycode/LICENSE-MIT.txt;md5=ee9bd8b835cfcd512dd644540dd96987 \
                    file://node_modules/glossy/LICENSE;md5=04598f95a1adcdfb9181e68cbcaea47e \
                    file://node_modules/unix-dgram/LICENSE;md5=1446bae1883758d95cb9a38560963fe9 \
                    file://node_modules/aproba/LICENSE;md5=9d215c9223fbef14a4642cc450e7ed4b \
                    file://node_modules/remove-trailing-separator/license;md5=294c1c7712f9be26cef730b5ad95a6a5 \
                    file://node_modules/lru-cache/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/one-time/LICENSE;md5=4310a14e1d911cc6e4b5a34dbcbeaddd \
                    file://node_modules/safe-buffer/LICENSE;md5=badd5e91c737e7ffdf10b40c1f907761 \
                    file://node_modules/winston-syslog/LICENSE;md5=207f20dc9776b79d0aea3637bb06dc03 \
                    file://node_modules/es6-iterator/LICENSE;md5=3a0e4b466225c131d23df6171d246447 \
                    file://node_modules/is-arrayish/LICENSE;md5=e67c75e89656b80fd99cb7d30fb43102 \
                    file://node_modules/github-from-package/LICENSE;md5=aea1cde69645f4b99be4ff7ca9abcce1 \
                    file://node_modules/inflight/LICENSE;md5=90a3ca01a5efed8b813a81c6c8fa2e63 \
                    file://node_modules/zigbee-herdsman-converters/LICENSE;md5=d1455712aeab4e6c11dbca72e1c0ec27 \
                    file://node_modules/tar-fs/LICENSE;md5=9befe7026bf915886cd566a98117c80e \
                    file://node_modules/buffer-from/LICENSE;md5=46513463e8f7d9eb671a243f0083b2c6 \
                    file://node_modules/ext/LICENSE;md5=9892f85a586bbc7ec0d9410b8e369309 \
                    file://node_modules/ext/node_modules/type/LICENSE;md5=e15e007c4e29efd21edb3580e7211b9e \
                    file://node_modules/mkdir-recursive/LICENSE;md5=84dcc94da3adb52b53ae4fa38fe49e5d \
                    file://node_modules/bl/LICENSE.md;md5=455bc3781a009cf9a615e8622138814c \
                    file://node_modules/bl/node_modules/readable-stream/LICENSE;md5=a67a7926e54316d90c14f74f71080977 \
                    file://node_modules/zigbee-herdsman/LICENSE;md5=af7b83a5ff1162a26feb1a736e65b1f5 \
                    file://node_modules/zigbee-herdsman/node_modules/ms/license.md;md5=fd56fd5f1860961dfa92d313167c37a6 \
                    file://node_modules/zigbee-herdsman/node_modules/debug/LICENSE;md5=ddd815a475e7338b0be7a14d8ee35a99 \
                    file://node_modules/fast-json-stable-stringify/LICENSE;md5=febe55307df96f60ad763842f5a8ca6f \
                    file://node_modules/colorspace/LICENSE.md;md5=c306c558012a48012189a646e0635014 \
                    file://node_modules/object-assign/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/@dabh/diagnostics/LICENSE;md5=c306c558012a48012189a646e0635014 \
                    file://node_modules/escape-html/LICENSE;md5=f8746101546eeb9e4f6de64bb8bdf595 \
                    file://node_modules/mqtt-packet/LICENSE.md;md5=622e77e45833bb4f785aebc7e41c0bdb \
                    file://node_modules/mqtt-packet/node_modules/ms/license.md;md5=fd56fd5f1860961dfa92d313167c37a6 \
                    file://node_modules/mqtt-packet/node_modules/debug/LICENSE;md5=ddd815a475e7338b0be7a14d8ee35a99 \
                    file://node_modules/sprintf-js/LICENSE;md5=ab40451de4e35c90f1b663b4fbd314a9 \
                    file://node_modules/leven/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/wide-align/LICENSE;md5=9d215c9223fbef14a4642cc450e7ed4b \
                    file://node_modules/readable-stream/LICENSE;md5=a67a7926e54316d90c14f74f71080977 \
                    file://node_modules/has-unicode/LICENSE;md5=2bab5b1c26e9c44fc4e489bb98cfb196 \
                    file://node_modules/commist/LICENSE;md5=3f047b8c72633e56a5d2bddc7feaa719 \
                    file://node_modules/color/LICENSE;md5=2fdebf76c074642a861bf45bf4a8258e \
                    file://node_modules/extend/LICENSE;md5=33d9f7a91df276ec16aa941032ee1476 \
                    file://node_modules/number-is-nan/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/pump/LICENSE;md5=9befe7026bf915886cd566a98117c80e \
                    file://node_modules/encodeurl/LICENSE;md5=272621efa0ff4f18a73221e49ab60654 \
                    file://node_modules/debounce/LICENSE;md5=3ff25a3a15c428c20fe547f4fa5e76d3 \
                    file://node_modules/file-uri-to-path/LICENSE;md5=9513dc0b97137379cfabc81b60889174 \
                    file://node_modules/fresh/LICENSE;md5=373c2cf0978b37e434394a43b4cbbdb4 \
                    file://node_modules/path-is-absolute/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/inherits/LICENSE;md5=5b2ef2247af6d355ae9d9f988092d470 \
                    file://node_modules/color-convert/LICENSE;md5=9bdadfc9fbb3ab8d5a6d591bdbd52811 \
                    file://node_modules/expand-template/LICENSE;md5=a962d6824118a16b514469e71173ac14 \
                    file://node_modules/set-blocking/LICENSE.txt;md5=8fd106383180f7bbb8f534414fdf7d35 \
                    file://node_modules/git-last-commit/LICENSE;md5=eb823c439c73c82db33dbabd04869af5 \
                    file://node_modules/nan/LICENSE.md;md5=e6270b7774528599f2623a4aeb625829 \
                    file://node_modules/xtend/LICENSE;md5=66787c5cd698a0b30b358c7e30f500ca \
                    file://node_modules/parseurl/LICENSE;md5=e7842ed4f188e53e53c3e8d9c4807e89 \
                    file://node_modules/is-glob/LICENSE;md5=fad3c8b9c04b365012f3d6821f2dda61 \
                    file://node_modules/core-util-is/LICENSE;md5=6126e36127d20ec0e2f637204a5c68ff \
                    file://node_modules/duplexify/LICENSE;md5=9befe7026bf915886cd566a98117c80e \
                    file://node_modules/mimic-response/license;md5=d5f2a6dd0192dcc7c833e50bb9017337 \
                    file://node_modules/serve-static/LICENSE;md5=27b1707520b14d0bc890f4e75cd387b0 \
                    file://node_modules/decompress-response/license;md5=915042b5df33c31a6db2b37eadaa00e3 \
                    file://node_modules/glob-parent/LICENSE;md5=429b0fedc27562e9e8deba9a9585396d \
                    file://node_modules/slip/GPL-LICENSE.txt;md5=2c1778696d3ba68569a0352e709ae6b7 \
                    file://node_modules/slip/MIT-LICENSE.txt;md5=b136108764931d4b8b8aacf3ea1af2ff \
                    file://node_modules/ieee754/LICENSE;md5=56c3be003027d64d24ca6b69a2612f2f \
                    file://node_modules/path-dirname/license;md5=83e325e26e7a045eef3df8d1082df8c0 \
                    file://node_modules/on-finished/LICENSE;md5=1b1f7f9cec194121fdf616b971df7a7b \
                    file://node_modules/process-nextick-args/license.md;md5=216769dac98a78ec088ee7cc6fad1dfa \
                    file://node_modules/triple-beam/LICENSE;md5=6662ccc5390189c4606fb6b2f726360b \
                    file://node_modules/unpipe/LICENSE;md5=934ab86a8ab081ea0326add08d550739 \
                    file://node_modules/through2-filter/LICENSE;md5=8636046213b5488606f3472d43049c99 \
                    file://node_modules/logform/LICENSE;md5=69464058e29d977cf9b282e9d8a749e8 \
                    file://node_modules/logform/node_modules/ms/license.md;md5=2b8bc52ae6b7ba58e1629deabd53986f \
                    file://node_modules/are-we-there-yet/LICENSE;md5=039a23da29f56411e6d75d7b7bc9de13 \
                    file://node_modules/unc-path-regex/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/simple-get/LICENSE;md5=fb42e5aa12bb9e365d38b4b5691d6984 \
                    file://node_modules/base64-js/LICENSE;md5=ea9187ca93cdc4f71219d1675712e908 \
                    file://node_modules/is-absolute/LICENSE;md5=b2593528953061a799b5b34922f0064d \
                    file://node_modules/minimist/LICENSE;md5=aea1cde69645f4b99be4ff7ca9abcce1 \
                    file://node_modules/signal-exit/LICENSE.txt;md5=e29e20260a1c78dba16a233048565cde \
                    file://node_modules/delegates/License;md5=039225978c07bc42e8c0ef2f72b81c09 \
                    file://node_modules/gauge/LICENSE;md5=43abbc6f9093aea69560715033788727 \
                    file://node_modules/strip-ansi/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/console-control-strings/LICENSE;md5=43abbc6f9093aea69560715033788727 \
                    file://node_modules/split2/LICENSE;md5=a3b84061387696c9678867c878a6bbc3 \
                    file://node_modules/split2/node_modules/readable-stream/LICENSE;md5=a67a7926e54316d90c14f74f71080977 \
                    file://node_modules/is-stream/license;md5=915042b5df33c31a6db2b37eadaa00e3 \
                    file://node_modules/esprima/LICENSE.BSD;md5=e3c825c932a984958bafbac21e21f984 \
                    file://node_modules/zigbee2mqtt-frontend/LICENSE;md5=1ebbd3e34237af26da5dc08a4e440464 \
                    file://node_modules/zigbee2mqtt-frontend/dist/scripts/vendor.46f2f1bd08054c950eed.js.LICENSE.txt;md5=5cb5668e47c8b26579fca978b637f56b \
                    file://node_modules/kuler/LICENSE;md5=07760fd1a905b41fefdc3763afb5dca5 \
                    file://node_modules/destroy/LICENSE;md5=c8d3a30332ecb31cfaf4c0a06da18f5c \
                    file://node_modules/end-of-stream/LICENSE;md5=9befe7026bf915886cd566a98117c80e \
                    file://node_modules/typedarray/LICENSE;md5=6085b70b74c7dcf7df4e955725e3153d \
                    file://node_modules/etag/LICENSE;md5=6e8686b7b13dd7ac8733645a81842c4a \
                    file://node_modules/to-absolute-glob/LICENSE;md5=8a4b0e5fd41b2cf9072913a284384998 \
                    file://node_modules/mqtt/LICENSE.md;md5=261aa46f11e9a7bdbea1dea7eb8bcb6c \
                    file://node_modules/mqtt/node_modules/ms/license.md;md5=fd56fd5f1860961dfa92d313167c37a6 \
                    file://node_modules/mqtt/node_modules/debug/LICENSE;md5=ddd815a475e7338b0be7a14d8ee35a99 \
                    file://node_modules/fn.name/LICENSE;md5=d9584417fe22ac64739ce9eb464ef34c \
                    file://node_modules/chownr/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/code-point-at/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://package.json;md5=c6e1cf3a060b441667fb4a91a57db3dd \
                    file://node_modules/@dabh/diagnostics/package.json;md5=645ea576697798a17013dfa2a49ec9b0 \
                    file://node_modules/@serialport/binding-abstract/node_modules/debug/package.json;md5=d084346a689161b3c5a11df81c28acc4 \
                    file://node_modules/@serialport/binding-abstract/node_modules/ms/package.json;md5=b3ea7267a23f72028e774742792b114a \
                    file://node_modules/@serialport/binding-abstract/package.json;md5=54b2d81aef0e11dc80f5ee8bfa3004be \
                    file://node_modules/@serialport/binding-mock/node_modules/debug/package.json;md5=d084346a689161b3c5a11df81c28acc4 \
                    file://node_modules/@serialport/binding-mock/node_modules/ms/package.json;md5=b3ea7267a23f72028e774742792b114a \
                    file://node_modules/@serialport/binding-mock/package.json;md5=37d6bc179ea0ea71175491104e169bef \
                    file://node_modules/@serialport/bindings/node_modules/debug/package.json;md5=d084346a689161b3c5a11df81c28acc4 \
                    file://node_modules/@serialport/bindings/node_modules/ms/package.json;md5=b3ea7267a23f72028e774742792b114a \
                    file://node_modules/@serialport/bindings/package.json;md5=ca02656b4428dc1a4cfd7f66582862da \
                    file://node_modules/@serialport/parser-byte-length/package.json;md5=3da557d4db78cdb8d74df288e945b2c1 \
                    file://node_modules/@serialport/parser-cctalk/package.json;md5=cc3c1a5cd3b99cfe0448c80ef5477c52 \
                    file://node_modules/@serialport/parser-delimiter/package.json;md5=4eff6a7cf262bb4367ed5a7d597997c9 \
                    file://node_modules/@serialport/parser-inter-byte-timeout/package.json;md5=16c9fb872c606d1ad596595c5ec9ec29 \
                    file://node_modules/@serialport/parser-readline/package.json;md5=735e455b3d0a5a560d02d45eb36d6180 \
                    file://node_modules/@serialport/parser-ready/package.json;md5=5464f2fb91a1945c7fda431fbf4f5dd4 \
                    file://node_modules/@serialport/parser-regex/package.json;md5=0b93d5aaefaae7a212ea81e28cb3818d \
                    file://node_modules/@serialport/stream/node_modules/debug/package.json;md5=d084346a689161b3c5a11df81c28acc4 \
                    file://node_modules/@serialport/stream/node_modules/ms/package.json;md5=b3ea7267a23f72028e774742792b114a \
                    file://node_modules/@serialport/stream/package.json;md5=986923f3a30dab12e686655c77cf255f \
                    file://node_modules/agent-base/node_modules/debug/package.json;md5=d084346a689161b3c5a11df81c28acc4 \
                    file://node_modules/agent-base/node_modules/ms/package.json;md5=b3ea7267a23f72028e774742792b114a \
                    file://node_modules/agent-base/package.json;md5=a42525d35ca83a583af793fcb6780b56 \
                    file://node_modules/ajv/package.json;md5=bc185fb380e6969e7ae607dde40bc9c3 \
                    file://node_modules/ansi-regex/package.json;md5=fbd3a8909a47de214c7288046091267c \
                    file://node_modules/aproba/package.json;md5=617442ed4770d06ac955969e7dcf7b98 \
                    file://node_modules/are-we-there-yet/package.json;md5=386ebd73fb9d607ee175b947082764ef \
                    file://node_modules/argparse/package.json;md5=2bc829c736c7071f36ec6e08cd41ccfe \
                    file://node_modules/async/package.json;md5=4352ed13333ee61619386feb1caf0bfd \
                    file://node_modules/axios/package.json;md5=70bc2fc5ed5c0cd71876cb370937e20d \
                    file://node_modules/balanced-match/package.json;md5=fa13802cf9109f23db7cc107f33cbf0a \
                    file://node_modules/base64-js/package.json;md5=8c3c32ad06db4e10d96a32653de4f1c3 \
                    file://node_modules/bindings/package.json;md5=17005447df8440e0e386849b8fa2b682 \
                    file://node_modules/bl/node_modules/readable-stream/package.json;md5=3304d7c65a4909be72be1ee604ca8915 \
                    file://node_modules/bl/package.json;md5=facb4ebabe0584de5c3ab29596de13d0 \
                    file://node_modules/brace-expansion/package.json;md5=effd91994b1b7ddb8a33060ad4541e6a \
                    file://node_modules/buffer/package.json;md5=3220969a7bbdae1bc07082db98d43627 \
                    file://node_modules/buffer-crc32/package.json;md5=92a03a851f46c2053f1eda652d4d0193 \
                    file://node_modules/buffer-from/package.json;md5=d708da6e9719b6b3a221aedc7e1cbf92 \
                    file://node_modules/callback-stream/package.json;md5=53d91ab1ea457e3694c3495823cf5ccc \
                    file://node_modules/chownr/package.json;md5=d01f1cdebdcc543145948a7070c8d012 \
                    file://node_modules/code-point-at/package.json;md5=4e85e8a583ebac72e2065d9e576c92cf \
                    file://node_modules/color/package.json;md5=47b75c4ea12fe229f5da94f1751d3059 \
                    file://node_modules/color-convert/package.json;md5=51a202f6ab9b016f0f7219701f1f5e70 \
                    file://node_modules/color-name/package.json;md5=7599aecb8597ca603c711d49a83dab59 \
                    file://node_modules/color-string/package.json;md5=a8bbdd01349e37961453498afb427956 \
                    file://node_modules/colors/package.json;md5=4327d7f964260e081ec682385f046758 \
                    file://node_modules/colorspace/package.json;md5=487594af64f072e733ff7b3bc0eff67d \
                    file://node_modules/commist/package.json;md5=97bbd3ffe608fa96bdfae7b687c16b42 \
                    file://node_modules/concat-map/package.json;md5=85d8a674998927862b17adef4aa6a7b1 \
                    file://node_modules/concat-stream/package.json;md5=61caf8dd4ec0cd0fe58d27f28dc499d1 \
                    file://node_modules/console-control-strings/package.json;md5=501cc4421445f05407dd447de932f200 \
                    file://node_modules/core-util-is/package.json;md5=685b947d7cae341b1e6f305b205da7ae \
                    file://node_modules/d/package.json;md5=9e885a5c3b7354c3719596765a74565d \
                    file://node_modules/debounce/package.json;md5=565594f4a6553b261a9269336c4f0528 \
                    file://node_modules/debug/package.json;md5=71a7656944ffe50cc27ebe02491ae49b \
                    file://node_modules/decompress-response/package.json;md5=9e56985764eb519489acc898805a861a \
                    file://node_modules/deep-extend/package.json;md5=843d8bcf451f015c3a6b3930e0b6eaee \
                    file://node_modules/deep-object-diff/package.json;md5=89a90b895f260fe998f729944cc56f23 \
                    file://node_modules/delegates/package.json;md5=fa4a364036777c0cf422bee58a0c4e2d \
                    file://node_modules/depd/package.json;md5=b6682ec09424cb14ad83a252a6748f35 \
                    file://node_modules/destroy/package.json;md5=ea66becf61cc69aece23e86ea3caf921 \
                    file://node_modules/detect-libc/package.json;md5=32bbf729c7ec55592eda945fda7f36bf \
                    file://node_modules/duplexify/package.json;md5=0df7062a272713b8043c7e26c65cba28 \
                    file://node_modules/ee-first/package.json;md5=3ed21090e07ef5dd57729a77c4291cb9 \
                    file://node_modules/enabled/package.json;md5=20a2de7f7b543585c7b543d6a818e9f7 \
                    file://node_modules/encodeurl/package.json;md5=453a9bb10c91e0ec44f305b14e30ce82 \
                    file://node_modules/end-of-stream/package.json;md5=36be3e35e3740830415138528c4237d4 \
                    file://node_modules/es5-ext/package.json;md5=d91416902fe92219942e5f431f2a3492 \
                    file://node_modules/es6-iterator/package.json;md5=6b01ff7f1a37f28e8c55914ddc7c9b28 \
                    file://node_modules/es6-map/package.json;md5=2d42d0dd003d649885120a53b6857133 \
                    file://node_modules/es6-set/node_modules/es6-symbol/package.json;md5=49d63d093253215bd5e54280727a2d0d \
                    file://node_modules/es6-set/package.json;md5=2a085d1c457b008623794825b4b17f8e \
                    file://node_modules/es6-symbol/package.json;md5=11d938883655ecd6ff3f1ab18c874d4b \
                    file://node_modules/escape-html/package.json;md5=e9c758769fec9883d5ce3d30b8ee1047 \
                    file://node_modules/esprima/package.json;md5=0394ebc64b1f0c98e6b1e3fd65c2ee37 \
                    file://node_modules/etag/package.json;md5=fec91cc11e50ee734c65c2d703db3884 \
                    file://node_modules/event-emitter/package.json;md5=0dd11a662119aaf3db8638515040e77b \
                    file://node_modules/expand-template/package.json;md5=a9e8e18483d794d55770da2c197094a4 \
                    file://node_modules/ext/node_modules/type/package.json;md5=489c897d42f3a7cb210bf5931ecc9bba \
                    file://node_modules/ext/package.json;md5=fbc6580e36e031a516a70d2ef9bc332e \
                    file://node_modules/extend/package.json;md5=5074ec873b4010df5203d20e73e65246 \
                    file://node_modules/fast-deep-equal/package.json;md5=da1199afd6b2d7a1eaa9e30acd35f4e6 \
                    file://node_modules/fast-json-stable-stringify/package.json;md5=903a31da36d2259011d342196a9b1265 \
                    file://node_modules/fast-safe-stringify/package.json;md5=fa356d91f6a46ebd0cad8db8af5d2597 \
                    file://node_modules/fecha/package.json;md5=d748fe15e5684ee9205cb7144aa74c3d \
                    file://node_modules/file-uri-to-path/package.json;md5=65f30030f0e7b2eff552eaabd8bb1fe1 \
                    file://node_modules/finalhandler/package.json;md5=65618bd839fed72de71aea141e19e568 \
                    file://node_modules/fn.name/package.json;md5=eca907cd517111a73f4ad09dfde4b1de \
                    file://node_modules/follow-redirects/package.json;md5=ff9f5429f1e7a5774d9410620692fe20 \
                    file://node_modules/fresh/package.json;md5=193849cf18966de2814f4f6e85740069 \
                    file://node_modules/fs-constants/package.json;md5=4e7713db1ace1f383b9f5b99e37c799b \
                    file://node_modules/fs.realpath/package.json;md5=3aa3d67ce378e330e293496dd3b9a506 \
                    file://node_modules/gauge/package.json;md5=ea229b587fee704faaf9431b96678324 \
                    file://node_modules/git-last-commit/package.json;md5=d3827675185428b15a8afdb42822d123 \
                    file://node_modules/github-from-package/package.json;md5=25c5e50360ca384264b0ba2a27730c07 \
                    file://node_modules/glob/package.json;md5=7d0807efb6353ee0196cabbacbf210d7 \
                    file://node_modules/glob-parent/package.json;md5=04bf0952f710c774bd9c759b11998416 \
                    file://node_modules/glob-stream/package.json;md5=47584ff5fe8f5e5fb936923d3a137212 \
                    file://node_modules/glossy/package.json;md5=f30d29dc546c806c76307498dcc52bdc \
                    file://node_modules/has-unicode/package.json;md5=f14043c8a5d6df10d3671d83073d6883 \
                    file://node_modules/help-me/package.json;md5=d86d6925639e56170e500cdf83d34cd6 \
                    file://node_modules/http-errors/package.json;md5=a06fe43128e6fe26a6719f1a007b3ef7 \
                    file://node_modules/https-proxy-agent/node_modules/debug/package.json;md5=d084346a689161b3c5a11df81c28acc4 \
                    file://node_modules/https-proxy-agent/node_modules/ms/package.json;md5=b3ea7267a23f72028e774742792b114a \
                    file://node_modules/https-proxy-agent/package.json;md5=06df0ea6fa292d84919d77ee3c130fdf \
                    file://node_modules/humanize-duration/package.json;md5=71d6d8520c0ad0c454c08f08465754e6 \
                    file://node_modules/ieee754/package.json;md5=c99ba1a776f9fbc9e23b4f0f7bfb7b0d \
                    file://node_modules/inflight/package.json;md5=85ba25624378c23e1ee9b33d3d103bf0 \
                    file://node_modules/inherits/package.json;md5=f73908dab55d4259f3ed052ce9fb2fbb \
                    file://node_modules/ini/package.json;md5=b613cca593420ef7097ea40ac8705690 \
                    file://node_modules/is-absolute/package.json;md5=adf23a50e92728422cc4c8f8b4f67624 \
                    file://node_modules/is-arrayish/package.json;md5=f36e90dfef7a25040592b87ce36aba47 \
                    file://node_modules/is-extglob/package.json;md5=90ad861bbbc1f6ee662d11dd78cdc2fd \
                    file://node_modules/is-fullwidth-code-point/package.json;md5=6bd5a684a5081f2d099cb800cf53ebd6 \
                    file://node_modules/is-glob/package.json;md5=71cd690e8d61d506b7386ca44e6a4405 \
                    file://node_modules/is-negated-glob/package.json;md5=77c3a1ad981bade28a4def248fe56565 \
                    file://node_modules/is-relative/package.json;md5=7b057b23a10fa1d9df473f65f65745a2 \
                    file://node_modules/is-stream/package.json;md5=6eeac477476e9abde80201885e1b322d \
                    file://node_modules/is-unc-path/package.json;md5=91958b5b9765eca54085ec03d86bac4f \
                    file://node_modules/is-windows/package.json;md5=5a2ed52f501e3a4a772b50bf34c752eb \
                    file://node_modules/isarray/package.json;md5=a490f11007b2cc9d19c4a250592c2e71 \
                    file://node_modules/js-yaml/package.json;md5=d4f45e416ff0c536bf5776e8b4cd9cd3 \
                    file://node_modules/json-schema-traverse/package.json;md5=e706b186146b3f00005442861f98c091 \
                    file://node_modules/json-stable-stringify-without-jsonify/package.json;md5=69744d65822d7e582b6b611142564175 \
                    file://node_modules/kuler/package.json;md5=97efa0f5b0bbbcd07f58897d57d80dec \
                    file://node_modules/leven/package.json;md5=9d393e0b49dad8fe3f0f57803c2620d5 \
                    file://node_modules/logform/node_modules/ms/package.json;md5=a682078f64a677ddad1f50307a14b678 \
                    file://node_modules/logform/package.json;md5=eaf8540c244b5c77be79076506958b4c \
                    file://node_modules/lru-cache/package.json;md5=5facce3b29b46c909e27bd642d950a3f \
                    file://node_modules/mime/package.json;md5=624ef11f91e60b224942ff81b13d10c6 \
                    file://node_modules/mimic-response/package.json;md5=6c674f4bb2748b4b79033f00460e7a0d \
                    file://node_modules/minimatch/package.json;md5=b763d93b18d070a6449399d2e92d8c32 \
                    file://node_modules/minimist/package.json;md5=84505571ecc56b8071068f44de7c79b2 \
                    file://node_modules/mixin-deep/package.json;md5=fd8bd35a454d9d531a19876631e36c3e \
                    file://node_modules/mkdir-recursive/package.json;md5=392cd026d69199f8b1ef0b3ad5e87cbf \
                    file://node_modules/mkdirp-classic/package.json;md5=c28019637c85bbadd156caaecad83c90 \
                    file://node_modules/moment/package.json;md5=5d9728f5a9fc2ae272061e8b08757505 \
                    file://node_modules/mqtt/node_modules/debug/package.json;md5=d084346a689161b3c5a11df81c28acc4 \
                    file://node_modules/mqtt/node_modules/ms/package.json;md5=b3ea7267a23f72028e774742792b114a \
                    file://node_modules/mqtt/package.json;md5=e21a51dabcbd0529625e2c0ee1e612e7 \
                    file://node_modules/mqtt-packet/node_modules/debug/package.json;md5=d084346a689161b3c5a11df81c28acc4 \
                    file://node_modules/mqtt-packet/node_modules/ms/package.json;md5=b3ea7267a23f72028e774742792b114a \
                    file://node_modules/mqtt-packet/package.json;md5=3712993b554511a0003a8275b7a54c9d \
                    file://node_modules/ms/package.json;md5=cbd55880a650b56c3d5acddbbdbee9bc \
                    file://node_modules/nan/package.json;md5=3cfe1e5a98bb9fe54ff73d4aef6df453 \
                    file://node_modules/napi-build-utils/package.json;md5=427a009ecbca39a81ee0424b6746a493 \
                    file://node_modules/next-tick/package.json;md5=f5d001dc2fe92d013b45aad2619b1441 \
                    file://node_modules/node-abi/node_modules/semver/package.json;md5=735f6ede2a644d292066a9813d8b9da6 \
                    file://node_modules/node-abi/package.json;md5=f7e9c67c2b3327fbc9c284a99d6de109 \
                    file://node_modules/noop-logger/package.json;md5=3cb8cc26d8d8df48dcbe764110e7924c \
                    file://node_modules/npmlog/package.json;md5=5052e259f267dea1afa387baced17891 \
                    file://node_modules/number-is-nan/package.json;md5=2b5b5a279c98be57ebafdaa605a14584 \
                    file://node_modules/object-assign/package.json;md5=2854c33ba575a9ebc613d1a617ece277 \
                    file://node_modules/object-assign-deep/package.json;md5=d8efde8fd210e3a8c4fdebf961a5e92a \
                    file://node_modules/on-finished/package.json;md5=d08696acafdda765ba2fe878b287912a \
                    file://node_modules/once/package.json;md5=afb6ea3bdcad6397e11a71615bd06e3b \
                    file://node_modules/one-time/package.json;md5=3b1d2325ccd19319bf53a1346a5b34bc \
                    file://node_modules/ordered-read-streams/package.json;md5=93596fab51b8726c0e54e23f1f415a77 \
                    file://node_modules/parseurl/package.json;md5=5b1493bd775444f0994d0b1063db1900 \
                    file://node_modules/path-dirname/package.json;md5=e9b8273ed2f66600f0a2f59e44bc6d1f \
                    file://node_modules/path-is-absolute/package.json;md5=ef6e018bdf67b82ab1285bc799b5367b \
                    file://node_modules/prebuild-install/package.json;md5=51fc31ba187f6b7997352a60683724e6 \
                    file://node_modules/process-nextick-args/package.json;md5=6bd1fff965ff97b4aff54e6b4e382ed0 \
                    file://node_modules/pump/package.json;md5=aaae9cf98124b7abea552bfa6b4ec7d5 \
                    file://node_modules/pumpify/node_modules/pump/package.json;md5=cc3430e81098dc872172cf2f26c38eb0 \
                    file://node_modules/pumpify/package.json;md5=a91156cafd2dc43b5ba27c8a9d6246ed \
                    file://node_modules/punycode/package.json;md5=11e1d3e03bb34de07e247a480cebb0b0 \
                    file://node_modules/range-parser/package.json;md5=89b7cc42d2831a8061361ca29545f837 \
                    file://node_modules/rc/package.json;md5=dcf8f74e9fad2b9d45a0c5d70eba335d \
                    file://node_modules/readable-stream/package.json;md5=55d646ab9e50735393b18c874d0bd5ab \
                    file://node_modules/reinterval/package.json;md5=c593e53b7f2250477c36754ad13e516e \
                    file://node_modules/remove-trailing-separator/package.json;md5=ba6eed8cddd45e58dfc64c382f54e24e \
                    file://node_modules/rimraf/package.json;md5=8a6e756a56b9dc8f8f70e4099b4e92a0 \
                    file://node_modules/safe-buffer/package.json;md5=bd7ef6f38f0ba20882d2601bd3ecaf11 \
                    file://node_modules/semver/package.json;md5=e9c03558862c56298e0a595817448cc2 \
                    file://node_modules/send/node_modules/ms/package.json;md5=83b5d192dde33fb41adda4ce8b9eb521 \
                    file://node_modules/send/package.json;md5=3645cd9d22c03f5bc9b3dddfe795b348 \
                    file://node_modules/serialport/node_modules/debug/package.json;md5=d084346a689161b3c5a11df81c28acc4 \
                    file://node_modules/serialport/node_modules/ms/package.json;md5=b3ea7267a23f72028e774742792b114a \
                    file://node_modules/serialport/package.json;md5=227065fa84b7f2d646f23abf01baa047 \
                    file://node_modules/serve-static/package.json;md5=d9c0bf270eb80f5b87045c69b8d6c79b \
                    file://node_modules/set-blocking/package.json;md5=e37224b4c865b4464d6d41b1f8a870a4 \
                    file://node_modules/setprototypeof/package.json;md5=1541c2199513a8830073d21fe710bb0b \
                    file://node_modules/signal-exit/package.json;md5=37c7ccfe57d64fc58b6c352c0cd59083 \
                    file://node_modules/simple-concat/package.json;md5=62cc47c95a07d52d3fa315e1869631bd \
                    file://node_modules/simple-get/package.json;md5=0516389b46014e9d5d197350253d0a3f \
                    file://node_modules/simple-swizzle/package.json;md5=cab0b71a3d1f56f4207555d0828a9851 \
                    file://node_modules/slip/package.json;md5=436d148bd48aea8bb806c6dccecb43a8 \
                    file://node_modules/split2/node_modules/readable-stream/package.json;md5=3304d7c65a4909be72be1ee604ca8915 \
                    file://node_modules/split2/package.json;md5=7b67653baa4639408e4e5b32e3a4f6d8 \
                    file://node_modules/sprintf-js/package.json;md5=403904b398a71123fc7c5173dfbe5ffe \
                    file://node_modules/stack-trace/package.json;md5=075663afd2a274ef74b88c7df49dec2c \
                    file://node_modules/statuses/package.json;md5=ce09e65d18aa8425eac89e41fde1837a \
                    file://node_modules/stream-shift/package.json;md5=9c93cef656a43b92e760e7fefd2b725a \
                    file://node_modules/string-width/package.json;md5=97dfb4a5985832f6a8c070ca4481b96c \
                    file://node_modules/string_decoder/package.json;md5=4a56e8c1789fe3bc13c55f8fec7e3ce2 \
                    file://node_modules/strip-ansi/package.json;md5=0b615dc471f5f434dd297c8655ed0c7f \
                    file://node_modules/strip-json-comments/package.json;md5=1dfad7430c94d2f136604def66ed9854 \
                    file://node_modules/tar-fs/package.json;md5=01b3d2bdeed95f237acd3a27147d60c4 \
                    file://node_modules/tar-stream/node_modules/readable-stream/package.json;md5=3304d7c65a4909be72be1ee604ca8915 \
                    file://node_modules/tar-stream/package.json;md5=b4e9cc0d7745a075a2f9a572ad0fd845 \
                    file://node_modules/text-hex/package.json;md5=f1b3817b994ec9b47dd5653e7be2550d \
                    file://node_modules/through2/package.json;md5=c584f7fcdc313c175710c330eff82712 \
                    file://node_modules/through2-filter/package.json;md5=a825c5f32c0be2db317774f23d4e7cbe \
                    file://node_modules/to-absolute-glob/package.json;md5=f2cb8277b0a58ca19ae2e30ccd3061f7 \
                    file://node_modules/toidentifier/package.json;md5=2ecc7acf5b134a92fbc0b0999a02f84d \
                    file://node_modules/triple-beam/package.json;md5=17caf87bb40557ec8b3eda069f2d7187 \
                    file://node_modules/tunnel-agent/package.json;md5=36d88acec2f39b7b86a347a0d8117296 \
                    file://node_modules/type/package.json;md5=b7401a3a1c0982149932daaeb26e0568 \
                    file://node_modules/typedarray/package.json;md5=252085c44894a63cd58d8c343f2ba589 \
                    file://node_modules/unc-path-regex/package.json;md5=ce8dab00313733f52f6be99f46393afa \
                    file://node_modules/unique-stream/package.json;md5=9c1ef1faef868bd1daac446d7e6c452f \
                    file://node_modules/unix-dgram/package.json;md5=9dffde473318920d2c796a36bc404492 \
                    file://node_modules/unpipe/package.json;md5=f8318a554ed98c6a030942e9c14aaac8 \
                    file://node_modules/uri-js/package.json;md5=7c79a9087e2e5f406201efae4c65b75b \
                    file://node_modules/util-deprecate/package.json;md5=73e6c3ff1709538c921d13a75cae485d \
                    file://node_modules/wide-align/package.json;md5=b408a19d562c2232e6d09bd6fc51a4a9 \
                    file://node_modules/winston/node_modules/readable-stream/package.json;md5=3304d7c65a4909be72be1ee604ca8915 \
                    file://node_modules/winston/package.json;md5=41fa0d19d3f52648d56e6f499859f593 \
                    file://node_modules/winston-syslog/package.json;md5=380fee86dd740a6d8dc5baf60a978f57 \
                    file://node_modules/winston-transport/package.json;md5=77f4a6f2c432437c28680723a3071cdb \
                    file://node_modules/wrappy/package.json;md5=788804d507f3ed479ea7614fa7d3f1a5 \
                    file://node_modules/ws/package.json;md5=b7aebe19a52fb524ad9370e1de4046a7 \
                    file://node_modules/xtend/package.json;md5=9a88dd08c469a5a8b2ea15f999bf5db8 \
                    file://node_modules/yallist/package.json;md5=b15d27bf2cf04083fef9389ce68aa620 \
                    file://node_modules/zigbee-herdsman/node_modules/debug/package.json;md5=d084346a689161b3c5a11df81c28acc4 \
                    file://node_modules/zigbee-herdsman/node_modules/ms/package.json;md5=b3ea7267a23f72028e774742792b114a \
                    file://node_modules/zigbee-herdsman/package.json;md5=0a3b2175ebbd2613e5cfe514dd86db23 \
                    file://node_modules/zigbee-herdsman-converters/package.json;md5=1fd8e97045350f35ed7ae8c07905e283 \
                    file://node_modules/zigbee2mqtt-frontend/package.json;md5=b2c39d11d78e885ed23bfd6d221fa122"

SRC_URI = " \
    https://github.com/Koenkk/zigbee2mqtt/archive/1.18.3.tar.gz \
    npmsw://${THISDIR}/${BPN}/npm-shrinkwrap.json \
    "
SRC_URI[md5sum] = "8bd8e061c879956c2654ea097afa641c"
SRC_URI[sha1sum] = "cf5c821eac173dacde8833aa6bb301649e0e9995"
SRC_URI[sha256sum] = "52718d37345a0f05ea1cb1b36552081c85a2477333507c6ed78d84cf6692fe84"
SRC_URI[sha384sum] = "d45ab9f431d96da40af89a40d27bdcc69c905f1206cb233aa150127dcbc733106f37b6f224d76460c8dff609051106e6"
SRC_URI[sha512sum] = "c9925b87828d0e9753dd3c63c1a93acbfd80be0c87f52d1cf867eb27852647f09ec7a9a2971c5df8db29106125bdbe4eb000dd5c970394c730e6e102fe125b9e"

inherit npm

LICENSE_${PN} = "GPLv3"
LICENSE_${PN}-dabh-diagnostics = "MIT"
LICENSE_${PN}-serialport-binding-abstract-debug = "MIT"
LICENSE_${PN}-serialport-binding-abstract-ms = "MIT"
LICENSE_${PN}-serialport-binding-abstract = "MIT"
LICENSE_${PN}-serialport-binding-mock-debug = "MIT"
LICENSE_${PN}-serialport-binding-mock-ms = "MIT"
LICENSE_${PN}-serialport-binding-mock = "MIT"
LICENSE_${PN}-serialport-bindings-debug = "MIT"
LICENSE_${PN}-serialport-bindings-ms = "MIT"
LICENSE_${PN}-serialport-bindings = "MIT"
LICENSE_${PN}-serialport-parser-byte-length = "MIT"
LICENSE_${PN}-serialport-parser-cctalk = "MIT"
LICENSE_${PN}-serialport-parser-delimiter = "MIT"
LICENSE_${PN}-serialport-parser-inter-byte-timeout = "MIT"
LICENSE_${PN}-serialport-parser-readline = "MIT"
LICENSE_${PN}-serialport-parser-ready = "MIT"
LICENSE_${PN}-serialport-parser-regex = "MIT"
LICENSE_${PN}-serialport-stream-debug = "MIT"
LICENSE_${PN}-serialport-stream-ms = "MIT"
LICENSE_${PN}-serialport-stream = "MIT"
LICENSE_${PN}-agent-base-debug = "MIT"
LICENSE_${PN}-agent-base-ms = "MIT"
LICENSE_${PN}-agent-base = "Unknown"
LICENSE_${PN}-ajv = "MIT"
LICENSE_${PN}-ansi-regex = "MIT"
LICENSE_${PN}-aproba = "ISC"
LICENSE_${PN}-are-we-there-yet = "ISC"
LICENSE_${PN}-argparse = "MIT"
LICENSE_${PN}-async = "MIT"
LICENSE_${PN}-axios = "MIT"
LICENSE_${PN}-balanced-match = "Unknown"
LICENSE_${PN}-base64-js = "MIT"
LICENSE_${PN}-bindings = "MIT"
LICENSE_${PN}-bl-readable-stream = "Unknown"
LICENSE_${PN}-bl = "Unknown"
LICENSE_${PN}-brace-expansion = "MIT"
LICENSE_${PN}-buffer = "MIT"
LICENSE_${PN}-buffer-crc32 = "MIT"
LICENSE_${PN}-buffer-from = "MIT"
LICENSE_${PN}-callback-stream = "Unknown"
LICENSE_${PN}-chownr = "ISC"
LICENSE_${PN}-code-point-at = "MIT"
LICENSE_${PN}-color = "MIT"
LICENSE_${PN}-color-convert = "MIT"
LICENSE_${PN}-color-name = "MIT"
LICENSE_${PN}-color-string = "MIT"
LICENSE_${PN}-colors = "Unknown"
LICENSE_${PN}-colorspace = "MIT"
LICENSE_${PN}-commist = "MIT"
LICENSE_${PN}-concat-map = "MIT"
LICENSE_${PN}-concat-stream = "MIT"
LICENSE_${PN}-console-control-strings = "ISC"
LICENSE_${PN}-core-util-is = "MIT"
LICENSE_${PN}-d = "ISC"
LICENSE_${PN}-debounce = "MIT"
LICENSE_${PN}-debug = "MIT"
LICENSE_${PN}-decompress-response = "MIT"
LICENSE_${PN}-deep-extend = "MIT"
LICENSE_${PN}-deep-object-diff = "MIT"
LICENSE_${PN}-delegates = "MIT"
LICENSE_${PN}-depd = "MIT"
LICENSE_${PN}-destroy = "MIT"
LICENSE_${PN}-detect-libc = "Unknown"
LICENSE_${PN}-duplexify = "MIT"
LICENSE_${PN}-ee-first = "MIT"
LICENSE_${PN}-enabled = "MIT"
LICENSE_${PN}-encodeurl = "MIT"
LICENSE_${PN}-end-of-stream = "MIT"
LICENSE_${PN}-es5-ext = "ISC"
LICENSE_${PN}-es6-iterator = "MIT"
LICENSE_${PN}-es6-map = "MIT"
LICENSE_${PN}-es6-set-es6-symbol = "MIT"
LICENSE_${PN}-es6-set = "MIT"
LICENSE_${PN}-es6-symbol = "ISC"
LICENSE_${PN}-escape-html = "MIT"
LICENSE_${PN}-esprima = "Unknown"
LICENSE_${PN}-etag = "MIT"
LICENSE_${PN}-event-emitter = "MIT"
LICENSE_${PN}-expand-template = "MIT"
LICENSE_${PN}-ext-type = "ISC"
LICENSE_${PN}-ext = "ISC"
LICENSE_${PN}-extend = "MIT"
LICENSE_${PN}-fast-deep-equal = "MIT"
LICENSE_${PN}-fast-json-stable-stringify = "MIT"
LICENSE_${PN}-fast-safe-stringify = "MIT"
LICENSE_${PN}-fecha = "MIT"
LICENSE_${PN}-file-uri-to-path = "MIT"
LICENSE_${PN}-finalhandler = "MIT"
LICENSE_${PN}-fnname = "MIT"
LICENSE_${PN}-follow-redirects = "MIT"
LICENSE_${PN}-fresh = "MIT"
LICENSE_${PN}-fs-constants = "MIT"
LICENSE_${PN}-fsrealpath = "Unknown"
LICENSE_${PN}-gauge = "ISC"
LICENSE_${PN}-git-last-commit = "MIT"
LICENSE_${PN}-github-from-package = "MIT"
LICENSE_${PN}-glob = "Unknown"
LICENSE_${PN}-glob-parent = "ISC"
LICENSE_${PN}-glob-stream = "MIT"
LICENSE_${PN}-glossy = "MIT"
LICENSE_${PN}-has-unicode = "ISC"
LICENSE_${PN}-help-me = "MIT"
LICENSE_${PN}-http-errors = "MIT"
LICENSE_${PN}-https-proxy-agent-debug = "MIT"
LICENSE_${PN}-https-proxy-agent-ms = "MIT"
LICENSE_${PN}-https-proxy-agent = "Unknown"
LICENSE_${PN}-humanize-duration = "Unknown"
LICENSE_${PN}-ieee754 = "Unknown"
LICENSE_${PN}-inflight = "ISC"
LICENSE_${PN}-inherits = "ISC"
LICENSE_${PN}-ini = "ISC"
LICENSE_${PN}-is-absolute = "MIT"
LICENSE_${PN}-is-arrayish = "MIT"
LICENSE_${PN}-is-extglob = "MIT"
LICENSE_${PN}-is-fullwidth-code-point = "MIT"
LICENSE_${PN}-is-glob = "MIT"
LICENSE_${PN}-is-negated-glob = "MIT"
LICENSE_${PN}-is-relative = "MIT"
LICENSE_${PN}-is-stream = "MIT"
LICENSE_${PN}-is-unc-path = "MIT"
LICENSE_${PN}-is-windows = "MIT"
LICENSE_${PN}-isarray = "Unknown"
LICENSE_${PN}-js-yaml = "MIT"
LICENSE_${PN}-json-schema-traverse = "MIT"
LICENSE_${PN}-json-stable-stringify-without-jsonify = "MIT"
LICENSE_${PN}-kuler = "MIT"
LICENSE_${PN}-leven = "MIT"
LICENSE_${PN}-logform-ms = "MIT"
LICENSE_${PN}-logform = "MIT"
LICENSE_${PN}-lru-cache = "ISC"
LICENSE_${PN}-mime = "MIT"
LICENSE_${PN}-mimic-response = "MIT"
LICENSE_${PN}-minimatch = "ISC"
LICENSE_${PN}-minimist = "MIT"
LICENSE_${PN}-mixin-deep = "MIT"
LICENSE_${PN}-mkdir-recursive = "GPLv3"
LICENSE_${PN}-mkdirp-classic = "MIT"
LICENSE_${PN}-moment = "MIT"
LICENSE_${PN}-mqtt-debug = "MIT"
LICENSE_${PN}-mqtt-ms = "MIT"
LICENSE_${PN}-mqtt = "Unknown"
LICENSE_${PN}-mqtt-packet-debug = "MIT"
LICENSE_${PN}-mqtt-packet-ms = "MIT"
LICENSE_${PN}-mqtt-packet = "Unknown"
LICENSE_${PN}-ms = "MIT"
LICENSE_${PN}-nan = "Unknown"
LICENSE_${PN}-napi-build-utils = "MIT"
LICENSE_${PN}-next-tick = "MIT"
LICENSE_${PN}-node-abi-semver = "ISC"
LICENSE_${PN}-node-abi = "MIT"
LICENSE_${PN}-noop-logger = "Unknown"
LICENSE_${PN}-npmlog = "ISC"
LICENSE_${PN}-number-is-nan = "MIT"
LICENSE_${PN}-object-assign = "MIT"
LICENSE_${PN}-object-assign-deep = "Unknown"
LICENSE_${PN}-on-finished = "MIT"
LICENSE_${PN}-once = "ISC"
LICENSE_${PN}-one-time = "MIT"
LICENSE_${PN}-ordered-read-streams = "MIT"
LICENSE_${PN}-parseurl = "MIT"
LICENSE_${PN}-path-dirname = "MIT"
LICENSE_${PN}-path-is-absolute = "MIT"
LICENSE_${PN}-prebuild-install = "MIT"
LICENSE_${PN}-process-nextick-args = "Unknown"
LICENSE_${PN}-pump = "MIT"
LICENSE_${PN}-pumpify-pump = "MIT"
LICENSE_${PN}-pumpify = "MIT"
LICENSE_${PN}-punycode = "MIT"
LICENSE_${PN}-range-parser = "MIT"
LICENSE_${PN}-rc = "MIT Unknown"
LICENSE_${PN}-readable-stream = "Unknown"
LICENSE_${PN}-reinterval = "MIT"
LICENSE_${PN}-remove-trailing-separator = "ISC"
LICENSE_${PN}-rimraf = "ISC"
LICENSE_${PN}-safe-buffer = "MIT"
LICENSE_${PN}-semver = "ISC"
LICENSE_${PN}-send-ms = "MIT"
LICENSE_${PN}-send = "MIT"
LICENSE_${PN}-serialport-debug = "MIT"
LICENSE_${PN}-serialport-ms = "MIT"
LICENSE_${PN}-serialport = "MIT"
LICENSE_${PN}-serve-static = "MIT"
LICENSE_${PN}-set-blocking = "ISC"
LICENSE_${PN}-setprototypeof = "ISC"
LICENSE_${PN}-signal-exit = "ISC"
LICENSE_${PN}-simple-concat = "MIT"
LICENSE_${PN}-simple-get = "MIT"
LICENSE_${PN}-simple-swizzle = "MIT"
LICENSE_${PN}-slip = "MIT Unknown"
LICENSE_${PN}-split2-readable-stream = "Unknown"
LICENSE_${PN}-split2 = "ISC"
LICENSE_${PN}-sprintf-js = "Unknown"
LICENSE_${PN}-stack-trace = "MIT"
LICENSE_${PN}-statuses = "MIT"
LICENSE_${PN}-stream-shift = "MIT"
LICENSE_${PN}-string-width = "MIT"
LICENSE_${PN}-stringdecoder = "Unknown"
LICENSE_${PN}-strip-ansi = "MIT"
LICENSE_${PN}-strip-json-comments = "MIT"
LICENSE_${PN}-tar-fs = "MIT"
LICENSE_${PN}-tar-stream-readable-stream = "Unknown"
LICENSE_${PN}-tar-stream = "MIT"
LICENSE_${PN}-text-hex = "MIT"
LICENSE_${PN}-through2 = "Unknown"
LICENSE_${PN}-through2-filter = "MIT"
LICENSE_${PN}-to-absolute-glob = "MIT"
LICENSE_${PN}-toidentifier = "MIT"
LICENSE_${PN}-triple-beam = "MIT"
LICENSE_${PN}-tunnel-agent = "Unknown"
LICENSE_${PN}-type = "ISC"
LICENSE_${PN}-typedarray = "Unknown"
LICENSE_${PN}-unc-path-regex = "MIT"
LICENSE_${PN}-unique-stream = "MIT"
LICENSE_${PN}-unix-dgram = "ISC"
LICENSE_${PN}-unpipe = "MIT"
LICENSE_${PN}-uri-js = "Unknown"
LICENSE_${PN}-util-deprecate = "MIT"
LICENSE_${PN}-wide-align = "ISC"
LICENSE_${PN}-winston-readable-stream = "Unknown"
LICENSE_${PN}-winston = "MIT"
LICENSE_${PN}-winston-syslog = "MIT"
LICENSE_${PN}-winston-transport = "MIT"
LICENSE_${PN}-wrappy = "ISC"
LICENSE_${PN}-ws = "MIT"
LICENSE_${PN}-xtend = "MIT"
LICENSE_${PN}-yallist = "ISC"
LICENSE_${PN}-zigbee-herdsman-debug = "MIT"
LICENSE_${PN}-zigbee-herdsman-ms = "MIT"
LICENSE_${PN}-zigbee-herdsman = "MIT"
LICENSE_${PN}-zigbee-herdsman-converters = "MIT"
LICENSE_${PN}-zigbee2mqtt-frontend = "Unknown"
